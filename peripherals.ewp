# IAR project peripherals.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: .\headers; ..\headers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: peripherals.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group source
    source/: configuration.c gpio.c main.c rtc.c system.c timer.c
  group source/CMSIS
    source/CMSIS/: system_stm32f1xx.c
  group source/headers
    source/headers/: configuration.h core_cm3.h core_cmFunc.h core_cmInstr.h gpio.h rtc.h stm32f103xb.h stm32f1xx.h system.h system_stm32f1xx.h timer.h
  group source/startup
    source/startup/: startup_stm32f10x_md.s
